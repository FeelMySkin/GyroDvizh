# Keil uVision project SelfBalance.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G071CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SelfBalance
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Sources
    ./: Source.cpp periph_use.c dac_controller.cpp spi_controller.cpp mpu_controller.cpp adc_controller.cpp
  group Headers
    ./: defines.h Source.h periph_use.h dac_controller.h spi_controller.h mpu_controller.h adc_controller.h
software components: CMSIS:CORE 5.3.0, Device:STM32Cube LL:ADC 1.3.0, Device:STM32Cube LL:Common 1.3.0, Device:STM32Cube LL:DAC 1.3.0, Device:STM32Cube LL:DMA 1.3.0, Device:STM32Cube LL:EXTI 1.3.0, Device:STM32Cube LL:GPIO 1.3.0, Device:STM32Cube LL:PWR 1.3.0, Device:STM32Cube LL:RCC 1.3.0, Device:STM32Cube LL:SPI 1.3.0, Device:STM32Cube LL:TIM 1.3.0, Device:STM32Cube LL:USART 1.3.0, Device:STM32Cube LL:UTILS 1.3.0, Device:Startup 1.3.0
